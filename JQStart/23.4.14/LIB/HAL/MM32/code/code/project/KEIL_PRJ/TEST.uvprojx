# Keil uVision project TEST.uvprojx, settings and files
target MM32Series (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32F0010A1T MindMotion
  pack: MindMotion.MM32F0010_DFP.1.0.6
  cpu: IRAM(0x20000000,0x00000800) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: HAIER_V1_MM20220516 +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\DEVICE\MM32F0010\Include;..\DEVICE\MM32F0010\HAL_Lib\Inc;..\DEVICE\CMSIS\KEIL_Core;..\USER;..\SYSTEM\UART;..\SYSTEM\SYS;..\SYSTEM\DELAY;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\TIM;..\HARDWARE\EEPROM;..\HARDWARE\ADC;..\HARDWARE\BSP_IO;..\HARDWARE\WWDG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group STARTUP
    ../DEVICE/MM32F0010/Source/: system_mm32f0010.c
    ../DEVICE/MM32F0010/Source/KEIL_StartAsm/: startup_mm32f0010_keil.s
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIM/: bsp_tim.c
    ../HARDWARE/EEPROM/: sim_eeprom.c
    ../HARDWARE/BSP_IO/: ldo.c bsp_io.c
    ../HARDWARE/WWDG/: wwdg.c
  group SYSTEM
    ../SYSTEM/DELAY/: delay.c
    ../SYSTEM/SYS/: sys.c
    ../SYSTEM/UART/: uart.c
  group USER
    ../USER/: main.c module.c StandardSensorModule.c
  group HAL_Lib
    ../DEVICE/MM32F0010/HAL_Lib/Src/: hal_adc.c hal_crc.c hal_dbg.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
    ../HARDWARE/ADC/: adc.c
