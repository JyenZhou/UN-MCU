# IAR project example.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM4050 AnalogDevices ADuCM4050
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: ADI_DEBUG; __ADUCM4050__; __ADUCM4x50__
  ICCARM.CCIncludePath2: ..\..\..\Muska Drivers\Include; ..\..\..\Muska Drivers\Include\config; ..\..\..\Hardware; ..\..\..\Device Drviers\ADPD
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\Muska Drivers\Include\config; ..\..\..\Muska Drivers\Include
  OBJCOPY.OOCOutputFile: example.hex
  ILINK.IlinkOutputFile: example.out
  ILINK.IlinkIcfFile: ..\..\..\ADuCM4050-flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG; __ADUCM4050__; __ADUCM4x50__
  ICCARM.CCIncludePath2: ..\..\config; ..\..\..\..\..\Include; ..\..\..\..\..\Include\config
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: ..\..\..\..\..\Include\config; ..\..\..\..\..\Include
  ILINK.IlinkOutputFile: systick_example.out
  group App
    ../../adpd_example/: example188.c smoke_detect.c
  group Device/ADPD
    ../../../Device Drviers/ADPD/: AdpdDrv.c AdpdDrv.h
  group Hardware
    ../../../Hardware/: Hardware_BEEP.c Hardware_CLOCK.c Hardware_GPIO.c Hardware_I2C.c Hardware_RTC.c Hardware_SPI.c Hardware_UART.c
  group SignalProcess
    ../../../SignalProcess/: Interactive Digital Filter Design.txt
  group Support
    ../../../Muska Drivers/Source/drivers/beep/: adi_beep.c
    ../../../Muska Drivers/Source/drivers/dma/: adi_dma.c
    ../../../Muska Drivers/Source/drivers/gpio/: adi_gpio.c
    ../../../Muska Drivers/Source/drivers/i2c/: adi_i2c.c
    ../../../Muska Drivers/Source/drivers/pwr/: adi_pwr.c
    ../../../Muska Drivers/Source/drivers/rtc/: adi_rtc.c
    ../../../Muska Drivers/Source/drivers/spi/: adi_spi.c
    ../../../Muska Drivers/Source/drivers/tmr/: adi_tmr.c
    ../../../Muska Drivers/Source/drivers/uart/: adi_uart.c
  group System
    ../../../Muska Drivers/Source/: common.c system_ADuCM4050.c
    ../../../Muska Drivers/Source/IAR/: startup_ADuCM4050.s
